# IAR project usblib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1230C3PM TexasInstruments TM4C1230C3PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: usblib.srec
  ILINK.IlinkOutputFile: usblib.out
  group Source
    ./: usbbuffer.c usbdesc.c usbdma.c usbkeyboardmap.c usbmode.c usbringbuf.c usbtick.c usbulpi.c
    device/: usbdaudio.c usbdbulk.c usbdcdc.c usbdcdesc.c usbdcomp.c usbdconfig.c usbddfu-rt.c usbdenum.c usbdhandler.c usbdhid.c usbdhidgamepad.c usbdhidkeyb.c usbdhidmouse.c usbdmsc.c
    host/: usbhaudio.c usbhhid.c usbhhidkeyboard.c usbhhidmouse.c usbhhub.c usbhmsc.c usbhostenum.c usbhscsi.c
